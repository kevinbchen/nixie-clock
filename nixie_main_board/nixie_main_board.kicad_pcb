# Repository kevinbchen/nixie-clock

## KiCad design nixie_main_board/nixie_main_board.kicad_pcb

Parts:
BT1: Battery_Cell; BatteryHolder_Keystone_1058_1x2032
C1: 470uF; CP_Radial_D10.0mm_P7.50mm
C2: 220uF; CP_Radial_D10.0mm_P7.50mm
C3, C6, C8, C11: 0.1uF; C_Disc_D3.0mm_W1.6mm_P2.50mm
C4: 1500pF; C_Disc_D7.0mm_W2.5mm_P5.00mm
C5: 100pF; C_Disc_D7.0mm_W2.5mm_P5.00mm
C7: 3.3uF 250V; CP_Radial_D8.0mm_P3.80mm
C9, C10: 22pF; C_Disc_D3.8mm_W2.6mm_P2.50mm
D1: 1N4148; D_DO-35_SOD27_P7.62mm_Horizontal
D2: UF4004; D_DO-41_SOD81_P10.16mm_Horizontal
H1, H2, H3, H4: MountingHole_Pad; MountingHole_2.2mm_M2_Pad
J1, J2: Conn_02x05_Odd_Even; PinSocket_2x05_P2.54mm_Vertical
J3: USB_C_Receptacle_USB2.0; USB_C_Receptacle_JAE_DX07S024WJ3R400
J4: Conn_01x02_Male; PinHeader_1x02_P2.54mm_Vertical
J5: AVR-ISP-6; PinHeader_2x03_P2.54mm_Vertical
J6: Conn_01x01_Male; PinSocket_1x01_P2.54mm_Vertical
L1: 100uH; L_Radial_D9.5mm_P5.00mm_Fastron_07HVP
Q1: BC557; TO-92_Inline
Q2: IRL640; TO-220-3_Horizontal_TabDown
R1, R11, R12, R13, R14: 1; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R2: 1k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R3: 100; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R4: 330k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R5: 2.2k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R6: 220; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R7, R8, R9, R10: 5.1k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
SW1: RotaryEncoder_Switch; RotaryEncoder_Alps_EC11E-Switch_Vertical_H20mm
SW2, SW3: SW_Push; SW_PUSH_6mm_H13mm
U1: ATmega328P-PU; DIP-28_W7.62mm
U2: MC34063AP; DIP-8_W7.62mm
U5: DS3231M; SOIC-16W_7.5x10.3mm_P1.27mm
Y1: 16 MHz; Crystal_HC49-U_Vertical

Connections:
+5V: C1.1, C2.1, C3.1, C8.1, C11.1, J1.2, J3.A4 (VBUS), J3.A9 (VBUS), J3.B4 (VBUS), J3.B9 (VBUS), R1.1, R7.2, R8.2, R11.1, R12.1, R13.1, R14.1, U1.7 (VCC), U1.20 (AVCC), U1.21 (AREF), U2.6 (Vin), U5.2 (VCC)
+170V: C7.1, D2.1 (K), J2.1, J2.3, J2.5, J2.7, J2.9, J6.1, R4.1
/RX: J4.2, U1.2 (PD0)
/TX: J4.1, U1.3 (PD1)
/VBATT: BT1.1 (+), U5.14 (VBAT)
EN1: J1.4, U1.15 (PB1)
EN2: J1.6, U1.16 (PB2)
EN3: J1.8, U1.12 (PD6)
EN4: J1.10, U1.11 (PD5)
EN5: J1.9, U1.5 (PD3)
GND: BT1.2 (-), C1.2, C2.2, C3.2, C4.2, C5.2, C6.1, C7.2, C8.2, C9.2, C10.2, C11.2, H1.1, H2.1, H3.1, H4.1, J1.1, J2.2, J2.4, J2.6, J2.8, J2.10, J3.A1 (GND), J3.A12 (GND), J3.B1 (GND), J3.B12 (GND), J5.6 (GND), Q1.1 (C), Q2.3 (S), R2.2, R6.2, R9.1, R10.1, SW1.C, SW1.S2, SW2.2, SW3.2, U1.8 (GND), U1.22 (GND), U2.4 (GND), U5.5 (GND), U5.6 (GND), U5.7 (GND), U5.8 (GND), U5.9 (GND), U5.10 (GND), U5.11 (GND), U5.12 (GND), U5.13 (GND)
MISO: J5.1 (MISO), U1.18 (PB4)
MOSI: J5.4 (MOSI), SW3.1, U1.17 (PB3)
unnamed: C4.1, U2.3 (TC)
unnamed: C5.1, R3.2
unnamed: C6.2, R4.2, R5.1, U2.5 (Vfb)
unnamed: C9.1, U1.10 (XTAL2/PB7), Y1.1
unnamed: C10.1, U1.9 (XTAL1/PB6), Y1.2
unnamed: D1.1 (K), Q1.3 (E), Q2.1 (G)
unnamed: D1.2 (A), Q1.2 (B), R2.1, U2.2 (SwE)
unnamed: D2.2 (A), L1.2, Q2.2 (D), R3.1
unnamed: J3.A5 (CC1), R10.2
unnamed: J3.B5 (CC2), R9.2
unnamed: L1.1, R1.2, R11.2, R12.2, R13.2, R14.2, U2.1 (SwC), U2.7 (Ipk), U2.8 (DC)
unnamed: R5.2, R6.1
unnamed: R7.1, U1.28 (PC5), U5.16 (SCL)
unnamed: R8.1, U1.27 (PC4), U5.15 (SDA)
unnamed: SW1.A, U1.6 (PD4)
unnamed: SW1.B, U1.13 (PD7)
unnamed: SW1.S1, U1.26 (PC3)
unnamed: SW2.1, U1.14 (PB0)
unnamed: U1.4 (PD2), U5.3 (~INT/SQW)
RCLK: J1.7, U1.23 (PC0)
SCK: J5.3 (SCK), U1.19 (PB5)
SER: J1.3, U1.25 (PC2)
SRCLK: J1.5, U1.24 (PC1)
~RESET: J5.5 (~RST), U1.1 (~RESET/PC6)

Board: 2 copper layers, 127.0 x 45.7 mm, 48 parts (4 on the bottom side), 37 nets.

## KiCad design nixie_tube_board/nixie_tube_board.kicad_pcb

Parts:
C1, C2, C3, C4, C5, C6: 0.1uF; C_Disc_D3.0mm_W1.6mm_P2.50mm
H1, H2, H3, H4: MountingHole_Pad; MountingHole_2.2mm_M2_Pad
J1, J2: Conn_02x05_Odd_Even; PinHeader_2x05_P2.54mm_Vertical
N1, N2, N3, N4: IN-2; nixies-us-IN-12-DSUB
N5: IN-3; nixies-us-IN-3
Q1, Q2, Q3, Q4, Q9: MPSA42; TO-92_Inline
Q5, Q6, Q7, Q8: MPSA92; TO-92_Inline
R1, R3, R5, R7: 100k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R2, R4, R6, R8, R9, R10, R11, R12: 10k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R13: 47k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R14: 330k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
U1, U2: 74HC595; DIP-16_W7.62mm
U3, U4, U5, U6: 74141; DIP-16_W7.62mm

Connections:
+5V: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, J1.2, U1.10 (~SRCLR), U1.16 (VCC), U2.10 (~SRCLR), U2.16 (VCC), U3.5 (VCC), U4.5 (VCC), U5.5 (VCC), U6.5 (VCC)
+170V: J2.1, J2.3, J2.5, J2.7, J2.9, Q5.1 (E), Q6.1 (E), Q7.1 (E), Q8.1 (E), R1.1, R3.1, R5.1, R7.1, R14.1
EN1: J1.4, Q1.2 (B)
EN2: J1.6, Q2.2 (B)
EN3: J1.8, Q3.2 (B)
EN4: J1.10, Q4.2 (B)
EN5: J1.9, R13.2
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, H1.1, H2.1, H3.1, H4.1, J1.1, J2.2, J2.4, J2.6, J2.8, J2.10, Q9.1 (E), R2.2, R4.2, R6.2, R8.2, U1.8 (GND), U1.13 (~OE), U2.8 (GND), U2.13 (~OE), U3.12 (GND), U4.12 (GND), U5.12 (GND), U6.12 (GND)
unnamed: N1.0, U3.16 (~Q0)
unnamed: N1.1, U3.15 (~Q1)
unnamed: N1.2, U3.8 (~Q2)
unnamed: N1.3, U3.9 (~Q3)
unnamed: N1.4, U3.13 (~Q4)
unnamed: N1.5, U3.14 (~Q5)
unnamed: N1.6, U3.11 (~Q6)
unnamed: N1.7, U3.10 (~Q7)
unnamed: N1.8, U3.1 (~Q8)
unnamed: N1.9, U3.2 (~Q9)
unnamed: N1.A, R9.2
unnamed: N2.0, U4.16 (~Q0)
unnamed: N2.1, U4.15 (~Q1)
unnamed: N2.2, U4.8 (~Q2)
unnamed: N2.3, U4.9 (~Q3)
unnamed: N2.4, U4.13 (~Q4)
unnamed: N2.5, U4.14 (~Q5)
unnamed: N2.6, U4.11 (~Q6)
unnamed: N2.7, U4.10 (~Q7)
unnamed: N2.8, U4.1 (~Q8)
unnamed: N2.9, U4.2 (~Q9)
unnamed: N2.A, R10.2
unnamed: N3.0, U5.16 (~Q0)
unnamed: N3.1, U5.15 (~Q1)
unnamed: N3.2, U5.8 (~Q2)
unnamed: N3.3, U5.9 (~Q3)
unnamed: N3.4, U5.13 (~Q4)
unnamed: N3.5, U5.14 (~Q5)
unnamed: N3.6, U5.11 (~Q6)
unnamed: N3.7, U5.10 (~Q7)
unnamed: N3.8, U5.1 (~Q8)
unnamed: N3.9, U5.2 (~Q9)
unnamed: N3.A, R11.2
unnamed: N4.0, U6.16 (~Q0)
unnamed: N4.1, U6.15 (~Q1)
unnamed: N4.2, U6.8 (~Q2)
unnamed: N4.3, U6.9 (~Q3)
unnamed: N4.4, U6.13 (~Q4)
unnamed: N4.5, U6.14 (~Q5)
unnamed: N4.6, U6.11 (~Q6)
unnamed: N4.7, U6.10 (~Q7)
unnamed: N4.8, U6.1 (~Q8)
unnamed: N4.9, U6.2 (~Q9)
unnamed: N4.A, R12.2
unnamed: N5.A, R14.2
unnamed: N5.K, Q9.3 (C)
unnamed: Q1.1 (E), R2.1
unnamed: Q1.3 (C), Q5.2 (B), R1.2
unnamed: Q2.1 (E), R4.1
unnamed: Q2.3 (C), Q6.2 (B), R3.2
unnamed: Q3.1 (E), R6.1
unnamed: Q3.3 (C), Q7.2 (B), R5.2
unnamed: Q4.1 (E), R8.1
unnamed: Q4.3 (C), Q8.2 (B), R7.2
unnamed: Q6.3 (C), R10.1
unnamed: Q7.3 (C), R11.1
unnamed: Q8.3 (C), R12.1
unnamed: Q9.2 (B), R13.1
unnamed: Q5.3 (C), R9.1
unnamed: U1.1 (QB), U3.6 (B)
unnamed: U1.2 (QC), U3.7 (C)
unnamed: U1.3 (QD), U3.4 (D)
unnamed: U1.4 (QE), U4.3 (A)
unnamed: U1.5 (QF), U4.6 (B)
unnamed: U1.6 (QG), U4.7 (C)
unnamed: U1.7 (QH), U4.4 (D)
unnamed: U1.9 (QH'), U2.14 (SER)
unnamed: U1.15 (QA), U3.3 (A)
unnamed: U2.1 (QB), U5.6 (B)
unnamed: U2.2 (QC), U5.7 (C)
unnamed: U2.3 (QD), U5.4 (D)
unnamed: U2.4 (QE), U6.3 (A)
unnamed: U2.5 (QF), U6.6 (B)
unnamed: U2.6 (QG), U6.7 (C)
unnamed: U2.7 (QH), U6.4 (D)
unnamed: U2.15 (QA), U5.3 (A)
RCLK: J1.7, U1.12 (RCLK), U2.12 (RCLK)
SER: J1.3, U1.14 (SER)
SRCLK: J1.5, U1.11 (SRCLK), U2.11 (SRCLK)

Board: 2 copper layers, 127.0 x 45.7 mm, 46 parts (2 on the bottom side), 87 nets.

## Commit log

2022-01-30 Add title/date/revision
2022-02-11 Fix mpsa92 orientation
2022-02-11 Initial software
2022-04-18 Enclosure files
2022-04-18 Update dateTime on edit
2022-04-18 Generalize setEditIndex, introduce digitValues
2022-04-18 De-poison every 30 minutes
2022-04-18 12/24 hour setting
2022-04-18 Save settings to eeprom
2022-04-19 De-poison period setting
2022-07-08 Fix sense resistor values
